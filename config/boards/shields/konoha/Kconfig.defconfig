## config/boards/shields/konoha/Kconfig.defconfig
```kconfig
if KONOHA
config ZMK_KEYBOARD_NAME
    default "Kokoha Keyboard"
endif

config ZMK_SPLIT_ROLE_CENTRAL
    default y
```
